# Keil uVision project Examples_STM32F4VE_V2.0.uvprojx, settings and files
target Examples_STM32F4VE_V2.0 (6160000::V6.16::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Examples_STM32F4VE_V2.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Documents;../Libs;../Libs/WIZ;../Libs/WIZ/W5500;../Libs/xLibMicrocontrollers;../Components;../Communications;../Controls
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c sdio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Libs/Common
    ../Libs/xLibMicrocontrollers/Common/: xCircleBuffer.c xCircleBuffer.h xDataBuffer.c xDataBuffer.h xMemory.c xMemory.h xPort.h xRx.c xRx.h xRxReceiver.c xRxReceiver.h xRxRequest.c xRxRequest.h xRxTransaction.c xRxTransaction.h xTransferLayer.c xTransferLayer.h xTx.c xTx.h xTypes.h
  group Libs/WIZ
    ../Libs/WIZ/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../Libs/WIZ/W5500/: w5500.c w5500.h
  group Libs/WS2812
    ../Libs/WS2812/: WS2812.c WS2812.h WS2812_Config.h WS2812_Info.h
  group Controls
    ../Controls/: Config.h Control.c Control.h Info.h Types.h
  group Communications
    ../Communications/: RxRequests.c RxRequests.h RxTransactions.c RxTransactions.h
  group Components/SerialPort
    ../Components/SerialPort/: SerialPort_Config.h SerialPort_Info.h SerialPort_Types.h SerialPortUART_Component.c SerialPortUSB_Component.c SerialPort_Component.h
    ../Components/SerialPort/Controls/: SerialPort.c SerialPort.h
  group Components/SerialPort/Adapters
    ../Components/SerialPort/Adapters/: SerialPort_Adapters.h SerialPort_AdaptersConfig.h SerialPort_AdaptersInfo.h SerialPort_AdaptersTypes.h
  group Components/SerialPort/Adapters/UART
    ../Components/SerialPort/Adapters/UART/: SerialPortUART_Adapter.c SerialPortUART_Adapter.h SerialPortUART_AdapterConfig.h SerialPortUART_AdapterInfo.h SerialPortUART_AdapterTypes.h SerialPortUART_RxAdapter.c SerialPortUART_RxAdapter.h SerialPortUART_TxAdapter.c SerialPortUART_TxAdapter.h
  group Components/SerialPort/Adapters/USB
    ../Components/SerialPort/Adapters/USB/: SerialPortUSB_Adapter.c SerialPortUSB_Adapter.h SerialPortUSB_AdapterConfig.h SerialPortUSB_AdapterInfo.h SerialPortUSB_AdapterTypes.h SerialPortUSB_RxAdapter.c SerialPortUSB_RxAdapter.h SerialPortUSB_TxAdapter.c SerialPortUSB_TxAdapter.h
  group Components/TCPServer
    ../Components/TCPServer/: TCPServer_Config.h TCPServer_Info.h TCPServer_Types.h TCPServerWIZspi_Component.c TCPServer_Component.h
    ../Components/TCPServer/Controls/: TCPServer.c TCPServer.h
  group Components/TCPServer/Adapters
    ../Components/TCPServer/Adapters/: TCPServer_Adapters.h TCPServer_AdaptersConfig.h TCPServer_AdaptersInfo.h TCPServer_AdaptersTypes.h
  group Components/TCPServer/Adapters/WIZspi
    ../Components/TCPServer/Adapters/WIZspi/: TCPServerWIZspi_Adapter.c TCPServerWIZspi_Adapter.h TCPServerWIZspi_AdapterConfig.h TCPServerWIZspi_AdapterInfo.h TCPServerWIZspi_AdapterTypes.h TCPServerWIZspi_RxAdapter.c TCPServerWIZspi_RxAdapter.h TCPServerWIZspi_TxAdapter.c TCPServerWIZspi_TxAdapter.h
  group Components/RGBCups
    ../Components/RGBCups/: RGBCups_Component.c RGBCups_Config.h RGBCups_Info.h RGBCups_Types.h RGBCups_Component.h
    ../Components/RGBCups/Controls/: RGBCups.c RGBCups.h
    ../Components/RGBCups/Logic/: RGBCups_Logics.c RGBCups_Logics.h RGBCups_DrawManager.c RGBCups_DrawManager.h
  group Components/RGBCups/Adapters
    ../Components/RGBCups/Adapters/: RGBCup_Adapter.c RGBCup_Adapter.h RGBCup_AdapterConfig.h RGBCup_AdapterInfo.h RGBCup_AdapterTypes.h
  group Libs/OV2640
    ../Libs/OV2640/: OV2640_BrightnessTables.h OV2640_ContrastTables.h OV2640_Driver.c OV2640_Driver.h OV2640_InitializationTables.h OV2640_JPEG_Tables.h OV2640_LightModeTables.h OV2640_PixelFormatsTables.h OV2640_Registers.h OV2640_ResolutionTables.h OV2640_SaturationTables.h OV2640_SpecialEffectsTables.h OV2640_xVGA_Tables.h
  group Components/Camera
    ../Components/Camera/: Camera_Component.h Camera_Config.h Camera_Info.h Camera_Types.h CameraOV2640_Component.c
    ../Components/Camera/Controls/: Camera.c Camera.h
  group Components/Camera/Adapters
    ../Components/Camera/Adapters/: Camera_AdaptersConfig.h Camera_AdaptersInfo.h Camera_AdaptersTypes.h
  group Components/Camera/Adapters/OV2640
    ../Components/Camera/Adapters/OV2640/: OV2640_Adapter.c OV2640_Adapter.h OV2640_AdapterConfig.h OV2640_AdapterInfo.h OV2640_AdapterTypes.h
software components: CMSIS:CORE 5.6.0
